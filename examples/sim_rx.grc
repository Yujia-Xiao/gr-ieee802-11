<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>sim_rx</value></param>
<param><key>category</key><value>IEEE802.11</value></param>
<param><key>generate_options</key><value>hb</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bss_mac</value></param>
<param><key>value</key><value>[0xff, 0xff, 0xff, 0xff, 0xff, 0xff]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>chan_est</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dst_mac</value></param>
<param><key>value</key><value>[0x42, 0x42, 0x42, 0x42, 0x42, 0x42]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>encoding</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>ieee802_11.BPSK_1_2</value></param>
</block>
<block>
<key>ieee802_11_check_addr</key>
<param><key>id</key><value>ieee802_11_check_addr_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>src_mac</key><value>src_mac</value></param>
</block>
<block>
<key>ieee802_11_gen_frames</key>
<param><key>id</key><value>ieee802_11_gen_frames_0</value></param>
<param><key>ac</key><value>0</value></param>
<param><key>bss_mac</key><value>bss_mac</value></param>
<param><key>dst_mac</key><value>dst_mac</value></param>
<param><key>duration</key><value>0x0000</value></param>
<param><key>frame_type</key><value>1</value></param>
<param><key>src_mac</key><value>src_mac</value></param>
</block>
<block>
<key>ieee802_11_ofdm_parse_mac</key>
<param><key>id</key><value>ieee802_11_ofdm_parse_mac_0</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>log</key><value>False</value></param>
</block>
<block>
<key>pad_sink</key>
<param><key>id</key><value>pad_sink_0</value></param>
<param><key>type</key><value>message</value></param>
<param><key>label</key><value>ack_out</value></param>
<param><key>optional</key><value>True</value></param>
</block>
<block>
<key>pad_source</key>
<param><key>id</key><value>pad_source_0</value></param>
<param><key>label</key><value>in</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>src_mac</value></param>
<param><key>value</key><value>[0x23, 0x23, 0x23, 0x23, 0x23, 0x23]</value></param>
</block>
<block>
<key>wifi_phy_hier</key>
<param><key>id</key><value>wifi_phy_hier_0</value></param>
<param><key>chan_est</key><value>chan_est</value></param>
<param><key>encoding</key><value>encoding</value></param>
</block>
<connection><source_block_id>ieee802_11_check_addr_0</source_block_id><sink_block_id>ieee802_11_gen_frames_0</sink_block_id><source_key>out</source_key><sink_key>data input</sink_key></connection>
<connection><source_block_id>ieee802_11_check_addr_0</source_block_id><sink_block_id>ieee802_11_ofdm_parse_mac_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ieee802_11_gen_frames_0</source_block_id><sink_block_id>pad_sink_0</sink_block_id><source_key>out</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pad_source_0</source_block_id><sink_block_id>wifi_phy_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0</source_block_id><sink_block_id>ieee802_11_check_addr_0</sink_block_id><source_key>mac_out</source_key><sink_key>data input</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0</source_block_id><sink_block_id>wifi_phy_hier_0</sink_block_id><source_key>mac_out</source_key><sink_key>mac_in</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
