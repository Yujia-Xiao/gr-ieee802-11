<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>transmitter</value></param>
<param><key>category</key><value>IEEE802.11</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
<param><key>title</key><value>Transmitter</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>chan_est</value></param>
<param><key>choices</key><value>[0, 1]</value></param>
<param><key>value</key><value>1</value></param>
<param><key>label</key><value></value></param>
<param><key>labels</key><value>["LMS", "Linear Comb"]</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>encoding</value></param>
<param><key>choices</key><value>[0,1,2,3,4,5,6,7]</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Encoding</value></param>
<param><key>labels</key><value>["BPSK 1/2", "BPSK 3/4", "QPSK 1/2", "QPSK 3/4", "16QAM 1/2", "16QAM 3/4", "64QAM 2/3", "64QAM 3/4"]</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>frame_type</value></param>
<param><key>choices</key><value>[0, 1, 2]</value></param>
<param><key>value</key><value>2</value></param>
<param><key>label</key><value></value></param>
<param><key>labels</key><value>["Management","Control_ACK","Data"]</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>drop_down</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>pdu_length</value></param>
<param><key>converver</key><value>int_converter</value></param>
<param><key>value</key><value>500</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>1500</value></param>
<param><key>min</key><value>0</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>variable_slider</key>
<param><key>id</key><value>snr</value></param>
<param><key>converver</key><value>float_converter</value></param>
<param><key>value</key><value>10</value></param>
<param><key>label</key><value></value></param>
<param><key>max</key><value>30</value></param>
<param><key>min</key><value>-15</value></param>
<param><key>num_steps</key><value>1000</value></param>
<param><key>style</key><value>wx.SL_HORIZONTAL</value></param>
</block>
<block>
<key>blocks_add_xx</key>
<param><key>id</key><value>blocks_add_xx_0</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0_0</value></param>
<param><key>msg</key><value>pmt.intern("spare!!~~~")</value></param>
<param><key>period</key><value>1100</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>ieee802_11_ofdm_parse_mac</key>
<param><key>id</key><value>ieee802_11_ofdm_parse_mac_0</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>log</key><value>False</value></param>
</block>
<block>
<key>sim_tx</key>
<param><key>id</key><value>sim_tx_0</value></param>
<param><key>ac</key><value>0</value></param>
<param><key>bss_mac</key><value>[0xff, 0xff, 0xff, 0xff, 0xff, 0xff]</value></param>
<param><key>chan_est</key><value>chan_est</value></param>
<param><key>dst_mac</key><value>[0x42, 0x42, 0x42, 0x42, 0x42, 0x42]</value></param>
<param><key>duration</key><value>0x0000</value></param>
<param><key>encoding</key><value>encoding</value></param>
<param><key>frame_type</key><value>frame_type</value></param>
<param><key>msg</key><value>pmt.intern("".join("x" for i in range(pdu_length)))</value></param>
<param><key>period</key><value>1000</value></param>
<param><key>src_mac</key><value>[0x23, 0x23, 0x23, 0x23, 0x23, 0x23]</value></param>
</block>
<block>
<key>sim_tx</key>
<param><key>id</key><value>sim_tx_0_0</value></param>
<param><key>ac</key><value>0</value></param>
<param><key>bss_mac</key><value>[0xff, 0xff, 0xff, 0xff, 0xff, 0xff]</value></param>
<param><key>chan_est</key><value>chan_est</value></param>
<param><key>dst_mac</key><value>[0x42, 0x42, 0x42, 0x42, 0x42, 0x42]</value></param>
<param><key>duration</key><value>0x0000</value></param>
<param><key>encoding</key><value>encoding</value></param>
<param><key>frame_type</key><value>frame_type</value></param>
<param><key>msg</key><value>pmt.intern("".join("o" for i in range(pdu_length)))</value></param>
<param><key>period</key><value>1000</value></param>
<param><key>src_mac</key><value>[0x23, 0x23, 0x23, 0x23, 0x23, 0x23]</value></param>
</block>
<block>
<key>wifi_phy_hier</key>
<param><key>id</key><value>wifi_phy_hier_0_0_0</value></param>
<param><key>chan_est</key><value>chan_est</value></param>
<param><key>encoding</key><value>encoding</value></param>
</block>
<connection><source_block_id>blocks_add_xx_0</source_block_id><sink_block_id>wifi_phy_hier_0_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_0_0</source_block_id><sink_block_id>wifi_phy_hier_0_0_0</sink_block_id><source_key>strobe</source_key><sink_key>mac_in</sink_key></connection>
<connection><source_block_id>sim_tx_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>sim_tx_0_0</source_block_id><sink_block_id>blocks_add_xx_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0_0_0</source_block_id><sink_block_id>blocks_null_sink_0_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0_0_0</source_block_id><sink_block_id>ieee802_11_ofdm_parse_mac_0</sink_block_id><source_key>mac_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0_0_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
