<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>wx_gui</value></param>
</block>
<block>
<key>variable_chooser</key>
<param><key>id</key><value>encoding</value></param>
<param><key>choices</key><value>[0,1,2,3,4,5,6,7]</value></param>
<param><key>value</key><value>0</value></param>
<param><key>label</key><value>Encoding</value></param>
<param><key>labels</key><value>["BPSK 1/2", "BPSK 3/4", "QPSK 1/2", "QPSK 3/4", "16QAM 1/2", "16QAM 3/4", "64QAM 2/3", "64QAM 3/4"]</value></param>
<param><key>style</key><value>wx.RA_HORIZONTAL</value></param>
<param><key>type</key><value>radio_buttons</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>ac</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>blocks_complex_to_mag</key>
<param><key>id</key><value>blocks_complex_to_mag_0</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0_0</value></param>
<param><key>msg</key><value>msg</value></param>
<param><key>period</key><value>period</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_0</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>blocks_null_sink</key>
<param><key>id</key><value>blocks_null_sink_1</value></param>
<param><key>bus_conns</key><value>[[0,],]</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>type</key><value>float</value></param>
</block>
<block>
<key>blocks_pdu_to_tagged_stream</key>
<param><key>id</key><value>blocks_pdu_to_tagged_stream_0</value></param>
<param><key>type</key><value>float</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_tagged_stream_to_pdu</key>
<param><key>id</key><value>blocks_tagged_stream_to_pdu_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>tag</key><value>packet_len</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>bss_mac</value></param>
<param><key>value</key><value>[0xff, 0xff, 0xff, 0xff, 0xff, 0xff]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>chan_est</value></param>
<param><key>value</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>dst_mac</value></param>
<param><key>value</key><value>[0x42, 0x42, 0x42, 0x42, 0x42, 0x42]</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>duration</value></param>
<param><key>value</key><value>0x0000</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>encoding_0</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>ieee802_11.BPSK_1_2</value></param>
</block>
<block>
<key>es_source</key>
<param><key>id</key><value>es_source_0</value></param>
<param><key>eb</key><value>asap</value></param>
<param><key>nthreads</key><value>1</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>num_streams</key><value>1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>frame_type</value></param>
<param><key>type</key><value>intx</value></param>
<param><key>value</key><value>2</value></param>
</block>
<block>
<key>ieee802_11_channel_power</key>
<param><key>id</key><value>ieee802_11_channel_power_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>n_samples</key><value>15000</value></param>
</block>
<block>
<key>ieee802_11_csma</key>
<param><key>id</key><value>ieee802_11_csma_0</value></param>
<param><key>debug</key><value>False</value></param>
<param><key>threshold</key><value>1.6</value></param>
</block>
<block>
<key>ieee802_11_gen_frames</key>
<param><key>id</key><value>ieee802_11_gen_frames_0</value></param>
<param><key>ac</key><value>0</value></param>
<param><key>bss_mac</key><value>bss_mac</value></param>
<param><key>dst_mac</key><value>dst_mac</value></param>
<param><key>duration</key><value>0x0000</value></param>
<param><key>frame_type</key><value>frame_type</value></param>
<param><key>src_mac</key><value>src_mac</value></param>
</block>
<block>
<key>ieee802_11_ofdm_parse_mac</key>
<param><key>id</key><value>ieee802_11_ofdm_parse_mac_0</value></param>
<param><key>debug</key><value>True</value></param>
<param><key>log</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>msg</value></param>
<param><key>value</key><value>pmt.intern("Hello World!")</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>period</value></param>
<param><key>value</key><value>200</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>src_mac</value></param>
<param><key>value</key><value>[0x23, 0x23, 0x23, 0x23, 0x23, 0x23]</value></param>
</block>
<block>
<key>wifi_phy_hier</key>
<param><key>id</key><value>wifi_phy_hier_0</value></param>
<param><key>chan_est</key><value>chan_est</value></param>
<param><key>encoding</key><value>encoding</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_0</value></param>
<param><key>avg_alpha</key><value>0.02</value></param>
<param><key>average</key><value>True</value></param>
<param><key>decimal_places</key><value>2</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>max_value</key><value>100</value></param>
<param><key>min_value</key><value>0</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>samp_rate</key><value>1</value></param>
<param><key>show_gauge</key><value>True</value></param>
<param><key>title</key><value>Frame Error Rate</value></param>
<param><key>type</key><value>float</value></param>
<param><key>units</key><value>%</value></param>
</block>
<block>
<key>wxgui_numbersink2</key>
<param><key>id</key><value>wxgui_numbersink2_1</value></param>
<param><key>avg_alpha</key><value>0</value></param>
<param><key>average</key><value>False</value></param>
<param><key>decimal_places</key><value>10</value></param>
<param><key>factor</key><value>1.0</value></param>
<param><key>max_value</key><value>100</value></param>
<param><key>min_value</key><value>-100</value></param>
<param><key>number_rate</key><value>15</value></param>
<param><key>peak_hold</key><value>False</value></param>
<param><key>ref_level</key><value>0</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>show_gauge</key><value>True</value></param>
<param><key>title</key><value>Number Plot</value></param>
<param><key>type</key><value>float</value></param>
<param><key>units</key><value>Units</value></param>
</block>
<connection><source_block_id>blocks_complex_to_mag_0</source_block_id><sink_block_id>ieee802_11_channel_power_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_message_strobe_0_0</source_block_id><sink_block_id>ieee802_11_gen_frames_0</sink_block_id><source_key>strobe</source_key><sink_key>data input</sink_key></connection>
<connection><source_block_id>blocks_pdu_to_tagged_stream_0</source_block_id><sink_block_id>wxgui_numbersink2_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_tagged_stream_to_pdu_0</source_block_id><sink_block_id>es_source_0</sink_block_id><source_key>pdus</source_key><sink_key>schedule_event</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>blocks_complex_to_mag_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>es_source_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>es_source_0</source_block_id><sink_block_id>wifi_phy_hier_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_11_channel_power_0</source_block_id><sink_block_id>blocks_null_sink_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_11_channel_power_0</source_block_id><sink_block_id>wxgui_numbersink2_1</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>ieee802_11_csma_0</source_block_id><sink_block_id>wifi_phy_hier_0</sink_block_id><source_key>out</source_key><sink_key>mac_in</sink_key></connection>
<connection><source_block_id>ieee802_11_gen_frames_0</source_block_id><sink_block_id>ieee802_11_csma_0</sink_block_id><source_key>out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>ieee802_11_ofdm_parse_mac_0</source_block_id><sink_block_id>blocks_pdu_to_tagged_stream_0</sink_block_id><source_key>fer</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0</source_block_id><sink_block_id>blocks_null_sink_0</sink_block_id><source_key>1</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0</source_block_id><sink_block_id>ieee802_11_ofdm_parse_mac_0</sink_block_id><source_key>mac_out</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>wifi_phy_hier_0</source_block_id><sink_block_id>blocks_tagged_stream_to_pdu_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
